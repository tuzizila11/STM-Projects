# Keil uVision project motor_nucleo.uvprojx, settings and files
target motor_nucleo (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F412ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000-0x2003FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: motor_nucleo +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: MEM_UNIT_BYTES,ARM_MATH_CM4,MemUnit_T=uint8_T,MATLAB_PROJECT,USE_HAL_DRIVER,STM32F412Zx
  c include: ../Inc;        ../Drivers/STM32F4xx_HAL_Driver/Inc;        ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;        ../Drivers/CMSIS/Device/ST/STM32F4xx/Include;        ../Drivers/CMSIS/Include;        ../Drivers/CMSIS/Core/Include;        ../Drivers/CMSIS/DSP/Include;        ../motor_nucleo/Inc;        "../../../../../../Program Files/MATLAB/R2020a/simulink/include";        ../../../../../../MATLAB/STM32-MAT/STM32/addSrc/inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  group Application/MDK-ARM
    ./: startup_stm32f412zx.s
  group Application/User
    ../Src/: main.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_uart.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_ll_usb.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group MATLAB
    C:/MATLAB/STM32-MAT/STM32/addSrc/src/: getBuffPtr.c
    C:/Users/tuziz/Desktop/STM Projects/Matlab DC MOTOR Nucleo-F412ZG/motor_nucleo/Src/: motor_nucleo.c motor_nucleo_TIM.c motor_nucleo_USART.c rtGetInf.c rtGetNaN.c rt_nonfinite.c
software components: CMSIS:CORE 4.3.0
